# IAR project tinyusb_dev_dynamic_configuration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RP2040 RaspberryPi RP2040
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CFG_TUSB_MCU=OPT_MCU_RP2040; CFG_TUSB_OS=OPT_OS_PICO; LIB_BOOT_STAGE2=1; LIB_PICO_BIT_OPS=1; LIB_PICO_BIT_OPS_PICO=1; LIB_PICO_BOOTSEL_VIA_DOUBLE_RESET=1; LIB_PICO_DIVIDER=1; LIB_PICO_DIVIDER_HARDWARE=1; LIB_PICO_DOUBLE=1; LIB_PICO_DOUBLE_PICO=1; LIB_PICO_FIX_RP2040_USB_DEVICE_ENUMERATION=1; LIB_PICO_FLOAT=1; LIB_PICO_FLOAT_PICO=1; LIB_PICO_INT64_OPS=1; LIB_PICO_INT64_OPS_PICO=1; LIB_PICO_MALLOC=1; LIB_PICO_MEM_OPS=1; LIB_PICO_MEM_OPS_PICO=1; LIB_PICO_PLATFORM=1; LIB_PICO_PRINTF=1; LIB_PICO_PRINTF_PICO=1; LIB_PICO_RUNTIME=1; LIB_PICO_STANDARD_LINK=1; LIB_PICO_STDIO=1; LIB_PICO_STDIO_UART=1; LIB_PICO_STDLIB=1; LIB_PICO_SYNC=1; LIB_PICO_SYNC_CRITICAL_SECTION=1; LIB_PICO_SYNC_MUTEX=1; LIB_PICO_SYNC_SEM=1; LIB_PICO_TIME=1; LIB_PICO_UTIL=1; LIB_TINYUSB_BOARD=1; LIB_TINYUSB_DEVICE=1; PICO_BOARD="pico"; PICO_BUILD=1; PICO_CMAKE_BUILD_TYPE="Release"; PICO_COPY_TO_RAM=0; PICO_CXX_ENABLE_EXCEPTIONS=0; PICO_NO_FLASH=0; PICO_NO_HARDWARE=0; PICO_ON_DEVICE=1; PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1; PICO_RP2040_USB_DEVICE_UFRAME_FIX=1; PICO_TARGET_NAME="tinyusb_dev_dynamic_configuration"; PICO_USE_BLOCKED_RAM=0
  ICCARM.CCDiagSuppress: Pa039,Pe170
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\lib\tinyusb\examples\device\dynamic_configuration\src; ..\..\..\..\..\..\..\src\common\pico_stdlib\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_gpio\include; ..\..\..\..\..\..\..\src\common\pico_base\include; ..\..\..\..\generated\pico_base; ..\..\..\..\..\..\..\src\boards\include; ..\..\..\..\..\..\..\src\rp2_common\pico_platform\include; ..\..\..\..\..\..\..\src\rp2040\hardware_regs\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_base\include; ..\..\..\..\..\..\..\src\rp2040\hardware_structs\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_claim\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_sync\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_irq\include; ..\..\..\..\..\..\..\src\common\pico_sync\include; ..\..\..\..\..\..\..\src\common\pico_time\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_timer\include; ..\..\..\..\..\..\..\src\common\pico_util\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_uart\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_resets\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_clocks\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_pll\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_vreg\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_watchdog\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_xosc\include; ..\..\..\..\..\..\..\src\rp2_common\hardware_divider\include; ..\..\..\..\..\..\..\src\rp2_common\pico_runtime\include; ..\..\..\..\..\..\..\src\rp2_common\pico_printf\include; ..\..\..\..\..\..\..\src\common\pico_bit_ops\include; ..\..\..\..\..\..\..\src\common\pico_divider\include; ..\..\..\..\..\..\..\src\rp2_common\pico_double\include; ..\..\..\..\..\..\..\src\rp2_common\pico_float\include; ..\..\..\..\..\..\..\src\rp2_common\pico_malloc\include; ..\..\..\..\..\..\..\src\rp2_common\pico_bootrom\include; ..\..\..\..\..\..\..\src\common\pico_binary_info\include; ..\..\..\..\..\..\..\src\rp2_common\pico_stdio\include; ..\..\..\..\..\..\..\src\rp2_common\pico_stdio_uart\include; ..\..\..\..\..\..\..\src\rp2_common\boot_stage2\include; ..\..\..\..\..\..\..\src\rp2_common\boot_stage2\asminclude; ..\..\..\..\..\..\..\src\rp2_common\pico_int64_ops\include; ..\..\..\..\..\..\..\src\rp2_common\pico_mem_ops\include; ..\..\..\..\..\..\..\lib\tinyusb\src; ..\..\..\..\..\..\..\lib\tinyusb\src\common; ..\..\..\..\..\..\..\lib\tinyusb\hw; ..\..\..\..\..\..\..\src\rp2_common\pico_fix\rp2040_usb_device_enumeration\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_dev_dynamic_configuration.srec
  ILINK.IlinkOutputFile: tinyusb_dev_dynamic_configuration.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\src\rp2_common\pico_standard_link\memmap_default.icf
  ILINK.IlinkProgramEntryLabel: _entry_point
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CFG_TUSB_MCU=OPT_MCU_RP2040; CFG_TUSB_OS=OPT_OS_PICO; LIB_BOOT_STAGE2=1; LIB_PICO_BIT_OPS=1; LIB_PICO_BIT_OPS_PICO=1; LIB_PICO_BOOTSEL_VIA_DOUBLE_RESET=1; LIB_PICO_DIVIDER=1; LIB_PICO_DIVIDER_HARDWARE=1; LIB_PICO_DOUBLE=1; LIB_PICO_DOUBLE_PICO=1; LIB_PICO_FIX_RP2040_USB_DEVICE_ENUMERATION=1; LIB_PICO_FLOAT=1; LIB_PICO_FLOAT_PICO=1; LIB_PICO_INT64_OPS=1; LIB_PICO_INT64_OPS_PICO=1; LIB_PICO_MALLOC=1; LIB_PICO_MEM_OPS=1; LIB_PICO_MEM_OPS_PICO=1; LIB_PICO_PLATFORM=1; LIB_PICO_PRINTF=1; LIB_PICO_PRINTF_PICO=1; LIB_PICO_RUNTIME=1; LIB_PICO_STANDARD_LINK=1; LIB_PICO_STDIO=1; LIB_PICO_STDIO_UART=1; LIB_PICO_STDLIB=1; LIB_PICO_SYNC=1; LIB_PICO_SYNC_CRITICAL_SECTION=1; LIB_PICO_SYNC_MUTEX=1; LIB_PICO_SYNC_SEM=1; LIB_PICO_TIME=1; LIB_PICO_UTIL=1; LIB_TINYUSB_BOARD=1; LIB_TINYUSB_DEVICE=1; NDEBUG; PICO_BOARD="pico"; PICO_BUILD=1; PICO_CMAKE_BUILD_TYPE="Release"; PICO_COPY_TO_RAM=0; PICO_CXX_ENABLE_EXCEPTIONS=0; PICO_NO_FLASH=0; PICO_NO_HARDWARE=0; PICO_ON_DEVICE=1; PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1; PICO_RP2040_USB_DEVICE_UFRAME_FIX=1; PICO_TARGET_NAME="tinyusb_dev_dynamic_configuration"; PICO_USE_BLOCKED_RAM=0
  AARM.ADefines: as above
configuration MinSizeRel (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
configuration RelWithDebInfo (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  group lib/tinyusb/examples/device/dynamic_configuration/src
    ../../../../../../../lib/tinyusb/examples/device/dynamic_configuration/src/: main.c msc_disk.c usb_descriptors.c
  group lib/tinyusb/hw/bsp/rp2040
    ../../../../../../../lib/tinyusb/hw/bsp/rp2040/: family.c
  group lib/tinyusb/src
    ../../../../../../../lib/tinyusb/src/: tusb.c
  group lib/tinyusb/src/class/audio
    ../../../../../../../lib/tinyusb/src/class/audio/: audio_device.c
  group lib/tinyusb/src/class/cdc
    ../../../../../../../lib/tinyusb/src/class/cdc/: cdc_device.c
  group lib/tinyusb/src/class/dfu
    ../../../../../../../lib/tinyusb/src/class/dfu/: dfu_device.c dfu_rt_device.c
  group lib/tinyusb/src/class/hid
    ../../../../../../../lib/tinyusb/src/class/hid/: hid_device.c
  group lib/tinyusb/src/class/midi
    ../../../../../../../lib/tinyusb/src/class/midi/: midi_device.c
  group lib/tinyusb/src/class/msc
    ../../../../../../../lib/tinyusb/src/class/msc/: msc_device.c
  group lib/tinyusb/src/class/net
    ../../../../../../../lib/tinyusb/src/class/net/: ecm_rndis_device.c ncm_device.c
  group lib/tinyusb/src/class/usbtmc
    ../../../../../../../lib/tinyusb/src/class/usbtmc/: usbtmc_device.c
  group lib/tinyusb/src/class/vendor
    ../../../../../../../lib/tinyusb/src/class/vendor/: vendor_device.c
  group lib/tinyusb/src/class/video
    ../../../../../../../lib/tinyusb/src/class/video/: video_device.c
  group lib/tinyusb/src/common
    ../../../../../../../lib/tinyusb/src/common/: tusb_fifo.c
  group lib/tinyusb/src/device
    ../../../../../../../lib/tinyusb/src/device/: usbd.c usbd_control.c
  group lib/tinyusb/src/portable/raspberrypi/rp2040
    ../../../../../../../lib/tinyusb/src/portable/raspberrypi/rp2040/: dcd_rp2040.c rp2040_usb.c
  group src/common/pico_sync
    ../../../../../../../src/common/pico_sync/: critical_section.c lock_core.c mutex.c sem.c
  group src/common/pico_time
    ../../../../../../../src/common/pico_time/: time.c timeout_helper.c
  group src/common/pico_util
    ../../../../../../../src/common/pico_util/: datetime.c pheap.c queue.c
  group src/rp2_common/boot_stage2
    ../../../../../../../src/rp2_common/boot_stage2/: compile_time_choice.S
  group src/rp2_common/hardware_claim
    ../../../../../../../src/rp2_common/hardware_claim/: claim.c
  group src/rp2_common/hardware_clocks
    ../../../../../../../src/rp2_common/hardware_clocks/: clocks.c
  group src/rp2_common/hardware_divider
    ../../../../../../../src/rp2_common/hardware_divider/: divider.S
  group src/rp2_common/hardware_gpio
    ../../../../../../../src/rp2_common/hardware_gpio/: gpio.c
  group src/rp2_common/hardware_irq
    ../../../../../../../src/rp2_common/hardware_irq/: irq.c irq_handler_chain.S
  group src/rp2_common/hardware_pll
    ../../../../../../../src/rp2_common/hardware_pll/: pll.c
  group src/rp2_common/hardware_sync
    ../../../../../../../src/rp2_common/hardware_sync/: sync.c
  group src/rp2_common/hardware_timer
    ../../../../../../../src/rp2_common/hardware_timer/: timer.c
  group src/rp2_common/hardware_uart
    ../../../../../../../src/rp2_common/hardware_uart/: uart.c
  group src/rp2_common/hardware_vreg
    ../../../../../../../src/rp2_common/hardware_vreg/: vreg.c
  group src/rp2_common/hardware_watchdog
    ../../../../../../../src/rp2_common/hardware_watchdog/: watchdog.c
  group src/rp2_common/hardware_xosc
    ../../../../../../../src/rp2_common/hardware_xosc/: xosc.c
  group src/rp2_common/pico_bit_ops
    ../../../../../../../src/rp2_common/pico_bit_ops/: bit_ops_aeabi.S
  group src/rp2_common/pico_bootrom
    ../../../../../../../src/rp2_common/pico_bootrom/: bootrom.c
  group src/rp2_common/pico_bootsel_via_double_reset
    ../../../../../../../src/rp2_common/pico_bootsel_via_double_reset/: pico_bootsel_via_double_reset.c
  group src/rp2_common/pico_divider
    ../../../../../../../src/rp2_common/pico_divider/: divider.S
  group src/rp2_common/pico_double
    ../../../../../../../src/rp2_common/pico_double/: double_aeabi.S double_init_rom.c double_math.c double_v1_rom_shim.S
  group src/rp2_common/pico_fix/rp2040_usb_device_enumeration
    ../../../../../../../src/rp2_common/pico_fix/rp2040_usb_device_enumeration/: rp2040_usb_device_enumeration.c
  group src/rp2_common/pico_float
    ../../../../../../../src/rp2_common/pico_float/: float_aeabi.S float_init_rom.c float_math.c float_v1_rom_shim.S
  group src/rp2_common/pico_int64_ops
    ../../../../../../../src/rp2_common/pico_int64_ops/: pico_int64_ops_aeabi.S
  group src/rp2_common/pico_malloc
    ../../../../../../../src/rp2_common/pico_malloc/: pico_malloc_iar.c
  group src/rp2_common/pico_mem_ops
    ../../../../../../../src/rp2_common/pico_mem_ops/: mem_ops_aeabi.S
  group src/rp2_common/pico_platform
    ../../../../../../../src/rp2_common/pico_platform/: platform.c
  group src/rp2_common/pico_printf
    ../../../../../../../src/rp2_common/pico_printf/: printf.c
  group src/rp2_common/pico_runtime
    ../../../../../../../src/rp2_common/pico_runtime/: runtime.c
  group src/rp2_common/pico_standard_link
    ../../../../../../../src/rp2_common/pico_standard_link/: binary_info.c crt0.S new_delete.cpp
  group src/rp2_common/pico_stdio
    ../../../../../../../src/rp2_common/pico_stdio/: stdio.c
  group src/rp2_common/pico_stdio_uart
    ../../../../../../../src/rp2_common/pico_stdio_uart/: stdio_uart.c
  group src/rp2_common/pico_stdlib
    ../../../../../../../src/rp2_common/pico_stdlib/: stdlib.c
